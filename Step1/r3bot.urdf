Commit message: adding revolute

File: Step1/r3bot.urdf (robot description, URDF)
Before this commit: robot r3bot, 6 links, 5 joints
Joints:
- joint joint2: type continuous -> revolute
